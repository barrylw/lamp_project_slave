# IAR project SlaverNode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030X8; AUTOSTART_ENABLE; PRINTF_DEBUG; USE_LORA_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: APP\; LIB\STM32F0xx_StdPeriph_Driver\inc; LIB\CMSIS\CM0\DeviceSupport\ST\STM32F0xx; LIB\CMSIS\CM0\CoreSupport; core; core\sys; platform; core\lib; tools\wpcapslip; core\cfs; OLED; coffee_arch
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SlaverNode.hex
  ILINK.IlinkOutputFile: SlaverNode.out
  ILINK.IlinkIcfFile: SlaverNode.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: APL.c apl_debug.c common.c contiki-main.c gpio_per.c hal_falsh.c hal_GDflash.c hal_led.c hal_memory.c hal_nvic.c hal_radio.c hal_rcc.c hal_timer.c hal_uart.c hal_wdg.c NWK.c os_cpu_a.asm PHY.c stm32f0xx_it.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
    platform/: clock.c
  group contiki/lib
    core/lib/: checkpoint.c crc16.c ifft.c list.c memb.c mmem.c print-stats.c random.c ringbuf.c settings.c trickle-timer.c
    core/sys/: ctimer.c energest.c etimer.c rtimer.c stimer.c timer.c
  group contiki/system
    core/sys/: autostart.c compower.c process.c procinit.c profile.c timetable-aggregate.c
    core/loader/: elfloader.c
  group LIB/CM0
    LIB/CMSIS/CM0/DeviceSupport/ST/STM32F0xx/: startup_stm32f030.s system_stm32f0xx.c
  group LIB/PER
    LIB/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
